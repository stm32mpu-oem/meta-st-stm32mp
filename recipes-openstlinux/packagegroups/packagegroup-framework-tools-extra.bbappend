FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

RDEPENDS:packagegroup-framework-tools-extra-network += "netcat-openbsd"

