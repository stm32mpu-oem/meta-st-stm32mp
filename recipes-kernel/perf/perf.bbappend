RDEPENDS:${PN}-tests =+ "bash"

PACKAGECONFIG:stm32mpcommon = "scripting tui libunwind coresight"
